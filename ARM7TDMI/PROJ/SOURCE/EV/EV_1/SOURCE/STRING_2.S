  AREA TEAM13,CODE,READONLY
	  ENTRY
	  LDR R0,=STRING        ;STRING ADDRESS
	  LDR R3,=0X40001000
	  LDR R4,=0X40001000
LOOP  LDRB R1,[R0],#1        ;LOADING SINGLE CHAR AND INCREMENTING
      STRB R1,[R3],#1        ;STORING IN DIFFERENT LOCATION
      ADD R2,R2,#1
	  CMP R1,#0
	  BNE LOOP
	  BL REVERSE             ;SUBROTUNE TO REVERSE
	  B NOPE
REVERSE
	  SUB R2,R2,#1
	  LSR R2,#1
	  SUB R3,R3,#1
LOOP2 LDRB R1,[R3]
	  LDRB R5,[R4]
	  STRB R1,[R4]
	  STRB R5,[R3]
	  SUB R3,R3,#1
	  ADD R4,R4,#1
	  SUB R2,R2,#1
	  CMP R2,#0
	  BNE LOOP2
      MOV PC,R14
NOPE  B NOPE
STRING DCB "TEAM 13 SHIVANAND RACHANNA SONAL ADITYA",0
      END
		  ;SPACE 144  BYTES
		  ;TIME  72.329